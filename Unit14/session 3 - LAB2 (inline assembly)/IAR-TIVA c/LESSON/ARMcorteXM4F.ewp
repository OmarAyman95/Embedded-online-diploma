# IAR project ARMcorteXM4F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: E:\microcontrollers\Embedded diploma2\4_Automotive and ARM cortex\01 Introduction To ARM Cortex M4 (STM32F4)(20H)\03 Lectures\01 ARM Architecture and STM32F4 Features(10.5H)\ARM practical\IAR\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ARMcorteXM4F.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\microcontrollers\Embedded diploma2\4_Automotive and ARM cortex\01 Introduction To ARM Cortex M4 (STM32F4)(20H)\03 Lectures\01 ARM Architecture and STM32F4 Features(10.5H)\ARM practical\IAR\LESSON\ARMcorteXM4F.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h
    ./: lm4f120h5qr.h main.c startup.c
